# Keil uVision project lab_04.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab_03
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src
    ./src/: gpio.c main.c timer.c globals.c handler.c uart.c adc.c
    ./src/startup/: startup.s
    ./src/arch/: utils.s lcd.s
  group include
    ./include/: systick.h gpio.h lcd.h timer.h globals.h handler.h uart.h adc.h
  group lib
    ./lib/: tm4c1294ncpdt.h
